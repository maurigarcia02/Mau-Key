File: _autosave-Mau Keys.kicad_pcb (KiCad board)
At the start: 2 copper layers, 256.2 x 181.3 mm, 47 parts

Commit message: Nueva geometria
Other:
- board size 256.2 x 181.3 mm -> 256.2 x 131.2 mm
